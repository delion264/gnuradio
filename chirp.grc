options:
  parameters:
    generate_options: qt_gui
    id: chirp
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: chirp_bw
  id: variable_qtgui_range
  parameters:
    start: '10000'
    step: '5'
    stop: '20000000'
    value: '2000000'
  states: {}
- name: chirp_rate
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: '1'
    stop: '10000'
    value: '2'
  states: {}
- name: doppler_shift
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '-1000000'
    step: '1'
    stop: '1000000'
    value: '0'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '8192'
  states: {}
- name: rx_delay
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '10000000'
    step: '1'
    stop: '100000000'
    value: '50000000'
  states: {}
- name: rx_delay
  id: variable
  parameters:
    value: '14000000'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: '100000000'
  states: {state: disabled}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    start: '2000000'
    step: '1'
    stop: '100000000'
    value: '100000000'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: '6'
  states: {state: disabled}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '20000000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: chirp_bw
    freq: chirp_rate
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: rx_delay
    type: complex
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: doppler_shift
    sample_rate: samp_rate
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '20'
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '20'
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: disabled}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: '1'
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    nthreads: '2'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    nthreads: '2'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: fft_vxx_2
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'False'
    nthreads: '2'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    type: ccc
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    name: '"Multiply Conj Freq Domain"'
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '16384'
    name: '"20log10(|fft|^2) post IFFT"'
    type: float
    ymax: '300'
    ymin: '-50'
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    name: '"20log10(|fft|^2) pre IFFT"'
    type: float
    ymax: '300'
    ymin: '-50'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"TX Time Domain"'
    size: '4096'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    update_time: '0.01'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '4096'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Time Domain pre IFFT"'
    size: fft_size
    srate: samp_rate
    tr_delay: '0.0'
    type: float
    update_time: '0.01'
    ymax: '100'
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"IFFT Time"'
    size: fft_size
    srate: samp_rate
    tr_level: 6e6
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    update_time: '0.07'
    ymax: 1e7
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    type: complex
    wintype: window.WIN_BLACKMAN
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    name: '"TX Freq Domain"'
    type: complex
    update_time: '0.02'
    wintype: window.WIN_BLACKMAN
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    int_max: '30'
    int_min: '-70'
    name: '"Cross correlation of TX with delayed RX"'
    type: complex
    update_time: '0.02'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_1_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    int_max: '30'
    int_min: '-120'
    name: '"Multiply Conj Waterfall"'
    type: float
    update_time: '0.02'
  states: {state: disabled}

connections:
- [analog_frequency_modulator_fc_0, '0', qtgui_time_sink_x_0_0, '0']
- [analog_frequency_modulator_fc_0, '0', qtgui_waterfall_sink_x_0, '0']
- [analog_sig_source_x_0_1, '0', blocks_throttle_0, '0']
- [analog_sig_source_x_1, '0', blocks_throttle_1, '0']
- [blocks_complex_to_mag_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_complex_to_mag_0, '0', qtgui_waterfall_sink_x_1_0, '0']
- [blocks_complex_to_mag_1, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_complex_to_mag_1, '0', qtgui_time_sink_x_2, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_delay_0, '0', blocks_freqshift_cc_0, '0']
- [blocks_freqshift_cc_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_nlog10_ff_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_nlog10_ff_0_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_1, '0']
- [blocks_stream_to_vector_1, '0', fft_vxx_2, '0']
- [blocks_throttle_0, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_throttle_1, '0', blocks_vco_c_0, '0']
- [blocks_vco_c_0, '0', blocks_delay_0, '0']
- [blocks_vco_c_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_vco_c_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vco_c_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_vector_to_stream_1, '0', blocks_complex_to_mag_1, '0']
- [blocks_vector_to_stream_1, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_vector_to_stream_1, '0', qtgui_waterfall_sink_x_1, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [fft_vxx_1, '0', blocks_vector_to_stream_0_0, '0']
- [fft_vxx_2, '0', blocks_vector_to_stream_1, '0']

metadata:
  file_format: 1
